# IAR project rtosdemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: AT91SAM7S128 Atmel AT91SAM7S128
  ICCARM.CCDefines: SAM7_IAR
  ICCARM.CCIncludePath2: ..\..\source\portable\iar\AtmelSAM7S64; ..\common\include; ..\..\source\include; SrcIAR; ..\App; USB_CDC; i2c; $PROJ_DIR$
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: srciar\; ..\..\include\; ..\common\include; ..\..\Source\include; ..\..\Source\portable\IAR\AtmelSAM7S64
  XLINK.XclFile: resource\at91SAM7S128_NoRemap.xcl
configuration Flash Bin (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  AARM.AUserIncludes: srciar\; ..\common\include; ..\..\Source\include; ..\..\Source\portable\IAR\AtmelSAM7S64
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../App/: Adc.c AT91SAM7SFlash.c Button.c cdc_enumerate.c DIP_switch.c ECom.c ext_irq.c Ext_ISR.s79 ExtUSART1_ISR.s79 Fallsensor.c GpIO.c IoCtrl.c Kogg.c Motor.c PWM.c RS485.c Sensors.c SpeedRegulator.c Timer.c timer0ISR.s79 timer1ISR.s79 UsbQ.c
    SrcIAR/: Cstartup.s79 Cstartup_SAM7.c
    ../../Source/portable/MemMang/: heap_1.c
    i2c/: I2C_interface.c I2C_TemperatureSensor.c
    ../../Source/: list.c queue.c tasks.c
    ./: main.c
    ../../Source/portable/IAR/AtmelSAM7S64/: port.c portasm.s79
    USB_CDC/: USB-CDC.c USB_ISR.s79 USBIsr.c
